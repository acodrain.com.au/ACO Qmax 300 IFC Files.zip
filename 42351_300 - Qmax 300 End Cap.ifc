Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: 42351_300.ifc
Time: 2024-01-03T06:21:41
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
